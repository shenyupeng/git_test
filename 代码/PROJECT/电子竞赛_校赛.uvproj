# Keil uVision project 电子竞赛_校赛.uvproj, settings and files
target 电子竞赛_校赛 (MCS-51)
  device: AT89F52 Atmel
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x1FFF) CLOCK(24000000)
  output: 电子竞赛_校赛 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\HARDWARE\LCD12864;..\HARDWARE\TIMER;..\HARDWARE\TLC5615;..\PROJECT;..\USER;..\HARDWARE\LCD1602
  group MAN
    ./: man.c
  group USER
    ../USER/: display.c algo.c
  group HARDWARE
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/TLC5615/: tlc5615.c
    ../HARDWARE/LCD12864/: Lcd12864.c
